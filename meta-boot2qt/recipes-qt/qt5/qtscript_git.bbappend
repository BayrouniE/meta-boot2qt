EXTRA_QMAKEVARS_PRE:append_arm = " CONFIG-=ltcg"
